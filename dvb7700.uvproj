# Keil uVision project dvb7700.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F120 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: dvb7700 +hex
  c flags: SizeSpeed=1
  group a file
    ./: L51_BANK.A51 STARTUP.A51
  group c file
    ./: CPUInit.c main.c adc.c timer.c uart.c rweeprom.c antenna.c protcol.c polar.c station.c SharpReceiver.c
  group h file
    ./: public.h cpu.h c8051f120.h station.h adc.h uart.h timer.h rweeprom.h math.h polar.h protcol.h sharp.h antenna.h xz_8802.h
  group 7700 c file
    ./: ITuner.c avl21081.c avl.c ExtSharpBS2S7HZ6306.c IBase.c IBSP.c IDiseqc.c IDVBSxRx.c II2C.c II2CRepeater.c
  group 7700 h file
    ./: ITuner.h avl2108.h avl.h bspdatadef.h ExtSharpBS2S7HZ6306.h IBase.h IBSP.h IDiseqc.h IDVBSxRx.h II2C.h II2CRepeater.h MyVariable.h
